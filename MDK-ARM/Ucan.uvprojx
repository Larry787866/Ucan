# Keil uVision project Ucan.uvprojx, settings and files
target cdc_acm (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F305RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.6.0
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cdc_acm +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER GD32F30X_CL
  c misc: --c99
  c include: ..\basic\Inc;..\User\inc;..\GD32F30x_standard_peripheral\Include;..\Conf\Inc;..\driver\Include;..\device\core\Include;..\device\class\cdc\Include;..\ustd\common;..\ustd\class\cdc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../User/src/: main.c gd32f30x_it.c systick.c Func.c gd32f30x_hw.c Protocal.c gsusb.c
  group CMSIS
    ../User/src/: system_gd32f30x.c
  group GD32F30x_Peripherals
    ../GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Startup
    ../basic/Src/: startup_gd32f30x_cl.s
  group Doc
    ../: readme.txt
  group Conf
    ../Conf/Src/: gpio.c can.c
  group USBFS
    ../device/core/Source/: usbd_core.c usbd_enum_ucan.c usbd_transc.c
    ../driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
    ../device/class/cdc/Source/: cdc_acm_core.c
software components: CMSIS:CORE 5.6.0
